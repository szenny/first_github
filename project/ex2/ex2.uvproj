# Keil uVision project ex2.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: ex2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group source file
    ../../KeilCode-5/EX2_c_code_compare_ab/: main.c
  group header file
    ../../KeilCode-5/EX2_c_code_compare_ab/: base.h
  group object file
    ../../KeilCode-5/EX2_c_code_compare_ab/: serial.o startup.o
