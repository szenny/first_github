# Keil uVision project sample2.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: sample2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x59999996 size 0x5eec00
  group source file
    ./: sample2.c conv.s
  group object file
    ../KeilCode_sample/EX1_main_call_asm_Helloworld/: startup.o serial.o
  group header file
    ../KeilCode_sample/EX2_c_code_compare_ab/: base.h
